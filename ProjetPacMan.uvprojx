# Keil uVision project ProjetPacMan.uvprojx, settings and files
target PacMAN (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Pacman +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\h
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Sources
    ./Sources/: main.c homescreen.c fantome.c boule.c GLCD.c GLCD_Fonts.c GLCD_MCBSTM32E.c timers.c
  group Headers
    ./h/: homescreen.h boule.h ext_globales.h fantome.h globales.h Board_GLCD.h Font_6x8_h.h Font_16x24_h.h GLCD_Config.h GLCD.h timers.h
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0
